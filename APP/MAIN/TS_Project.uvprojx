# Keil uVision project TS_Project.uvprojx, settings and files
target APU (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32E103VE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32E103_MINI,DEBUG_INFO_ENABLE,ARM_MATH_CM3,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\main;..\applications;..\..\OS\OS_Driver;..\..\OS\OS_Task;..\..\RTE;..\..\TYPES;..\..\RTE;..\..\LIB;..\..\BSW;..\..\Cfg\BSW_Cfg;..\..\MCAL;..\..\ext-driver;..\..\Cfg\MCAL_Cfg;..\..\APP;..\..\DRIVER\Chip_Driver\APM32E103VE\Library\Driver\CMSIS\Include;..\..\DRIVER\Chip_Driver\APM32E103VE\Library\Standard_Library\inc;..\..\DRIVER\Chip_Driver\APM32E103VE\User_Interface;..\..\OS\FreeRTOS\Source\include;..\..\OS\FreeRTOS\Source\portable\MemMang;..\..\OS\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x6f000
  memory RVCT9: RAM 0x20000000 size 0x1ffe0
  memory RVCT10: RAM 0x2001ffe0 size 0x20
  group APP
    ./: main.c
    ../: OS_TASK.c FreeRTOS_TASK.c
    ../applications/: APP_test.c APP_KEY_State_Get.c APP_LED_State.c APP_DEBUG_MODE.c APP_FIX_VALUE_MANAGE.c APP_SETTING_IN_FACTORY.c APP_Parameter.c APP_Scroll_storage.c APP_Protection_Backend.c APP_Protection_Management.c APP_LCD_Parameter_Configure.c APP_LCD_Run_Monitor.c APP_fault_management.c APP_Report_Display.c
  group OS
    ../../OS/OS_Driver/: Os_BaseTimer.c Os_EvtHdl.c Os_TimerHdl.c
    ../../OS/OS_Task/: Os_TaskHdl_Lv0.c Os_TaskHdl_Lv1.c Os_TaskHdl_Lv2.c
    ../../OS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../OS/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../OS/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group RTE
    ../../RTE/: RTE.c
  group Standard_Library
    ../../DRIVER/Chip_Driver/APM32E103VE/Library/Standard_Library/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_wwdt.c
  group Chip_Driver
    ../../DRIVER/Chip_Driver/APM32E103VE/User_Interface/: apm32e10x_int.c system_apm32e10x.c
    ../../DRIVER/Chip_Driver/APM32E103VE/Library/Driver/Startup/: startup_apm32e10x_hd.s
  group MCAL
    ../../MCAL/: MCAL_GPIO.c MCAL_ADC.c MCAL_DMA.c MCAL_SPI.c MCAL_UART.c MCAL_NVIC.c MCAL_Timer.c MCAL_RTC.c
  group MCAL-Cfg
    ../../Cfg/MCAL_Cfg/: MCAL_Cfg_ADC.c MCAL_Cfg_DMA.c MCAL_Cfg_SPI.c MCAL_Cfg_UART.c MCAL_Cfg_GPIO.c
  group BSW
    ../../BSW/: BSW_Adcif.c BSW_FFT_APP.c BSW_Dio.c BSW_NvM.c BSW_MODBUS.c BSW_CRC.c
  group BSW-Cfg
    ../../Cfg/BSW_Cfg/: BSW_Cfg_NvM.c BSW_Cfg_Modbus.c
  group LIB
    ../../LIB/: Lib_Log_Util.c cr4_fft_256_stm32.s cr4_fft_1024_stm32.s arm_cortexM3l_math.lib arm_atan2_f32.c
  group ext-driver
    ../../ext-driver/: Ext_LCD_Driver.c Lib_LCD_kernel.c Lib_LCD_menu.c Ext_MB85RS64.c Ext_KEY.c Ext_LED.c Lib_LCD_telemetry_first.c Lib_LCD_telemetry_second.c Lib_LCD_words.c Lib_LCD_char.c
